# IAR project Project.ewp, settings and files
configuration Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\User\bsp; ..\..\User\FatFS; ..\..\User\Fonts; ..\..\User
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: STM32F103ZE-EK.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CpuRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; VECT_TAB_SRAM
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: stm32f10x_ram.icf
configuration ExtSRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; VECT_TAB_SRAM
  ILINK.IlinkIcfFile: stm32f10x_extsram.icf
  group BSP
    ../../User/bsp/: bsp_button.c bsp_i2c_gpio.c bsp_led.c bsp_printf.c bsp_sdio_sd.c bsp_tft_lcd.c bsp_timer.c bsp_usart.c bsp_VS1003B.c bsp_WM8978.c
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Doc
    ../../: 例程说明(中文).txt
  group EWARMv5
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group FatFS
    ../../User/fatfs/: diskio.c ff.c
  group Fonts
    ../../User/fonts/: asc16.c hz16.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../../User/: main.c mp3_player.c stm32f10x_it.c

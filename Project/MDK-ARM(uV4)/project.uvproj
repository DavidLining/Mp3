# Keil uVision project project.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User\fatfs;..\..\User\fonts;..\..\User;..\..\User\images;..\..\User\USB_MASS\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver;..\..\STM32_EVAL;..\..\STM32_EVAL\STM3210C_EVAL;..\..\STM32_EVAL\STM3210B_EVAL;..\..\STM32_EVAL\STM3210E_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../User/: main.c stm32f10x_it.c mp3_player.c
  group BSP
    ../../User/bsp/: bsp_printf.c bsp_usart.c bsp_led.c bsp_timer.c bsp_button.c bsp_sdio_sd.c bsp_i2c_gpio.c bsp_VS1003B.c bsp_WM8978.c bsp_tft_lcd.c
  group MDK-ARM
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_fsmc.c
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Doc
    ../../: 例程说明(中文).txt
  group FatFS
    ../../User/fatfs/: diskio.c ff.c ff.h
    ../../User/fatfs/option/: cc936.c
  group Fonts
    ../../User/fonts/: asc16.c hz16.c
  group images
    ../../User/images/: images.c
  group USB_MASS
    ../../User/USB_MASS/src/: fsmc_nand.c hw_config.c mass_mal.c memory.c msd.c nand_if.c scsi_data.c sdcard.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group STM32_USB-FS-Device_Driver
    ../../Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32_EVAL
    ../../STM32_EVAL/: stm32_eval.c
target CpuRAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: output +hex
  AfterMake: CopyHex_CpuRAM.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User\fatfs;..\..\User\fonts;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
target ExtSRAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: output +hex
  AfterMake: CopyHex_ExtSRAM.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x68000000 size 0x80000
  memory RVCT9: RAM 0x20000200 size 0xffe00
